# Keil uVision project PID_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0x2FF) IROM(0-0x3FFF) CLOCK(12000000) MODP2
  output: PID_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: startup.a51 main.c A96L116_adc.c
